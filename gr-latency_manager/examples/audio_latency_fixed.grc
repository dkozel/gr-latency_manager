options:
  parameters:
    generate_options: qt_gui
    id: audio_latency
    output_language: python
    title: Audio Latency Demo
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_push_button
  parameters:
    gui_hint: '[10,0,1,10]'
    label: Send Tone
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude
    type: float
  states: {}
- name: latency_manager_latency_manager_0
  id: latency_manager_latency_manager
  parameters:
    max_tags_in_flight: '50'
    tag_interval: '1000'
    type: float
    vlen: '1'
  states: {}
- name: latency_manager_tag_to_msg_0
  id: latency_manager_tag_to_msg
  parameters:
    display: 'True'
    filter: '"latency_strobe"'
    issue_messages: 'True'
    name: ''
    num_inputs: '1'
    type: float
    vlen: '1'
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amp: '0.001'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: '[0,0,10,10]'
    name: '"Before Processing"'
    size: '512'
    srate: samp_rate
    type: float
    update_time: 1.0/60
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: '[11,0,10,10]'
    name: '"After Processing"'
    size: '512'
    srate: samp_rate
    tr_tag: '"latency_strobe"'
    type: float
    update_time: 1.0/60
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tokens
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tokens
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', audio_sink_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', latency_manager_tag_to_msg_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_const_vxx_0_0_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0_0_1, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_add_const_vxx_0_0_1, '0']
- [blocks_add_xx_0, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [latency_manager_latency_manager_0, '0', blocks_multiply_const_vxx_0, '0']
- [latency_manager_tag_to_msg_0, msg, virtual_sink_0, '0']
- [noise, '0', blocks_add_xx_0, '1']
- [tone, '0', latency_manager_latency_manager_0, '0']
- [virtual_source_0, '0', latency_manager_latency_manager_0, token]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-ga20232e9
