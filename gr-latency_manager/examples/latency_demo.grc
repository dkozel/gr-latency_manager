options:
  parameters:
    generate_options: qt_gui
    id: testing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_push_button
  parameters:
    label: Amplitude
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: latency_canary
  id: variable_tag_object
  parameters:
    key: pmt.intern("latency_canary")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.intern("unknown")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[latency_canary]'
    type: float
    vector: (1,)*100
  states: {}
- name: latency_manager_latency_manager_0
  id: latency_manager_latency_manager
  parameters:
    max_tags_in_flight: '10'
    tag_interval: '0'
    type: float
    vlen: '1'
  states: {}
- name: latency_manager_tag_to_msg_0
  id: latency_manager_tag_to_msg
  parameters:
    display: 'False'
    filter: '"latency_canary"'
    issue_messages: 'True'
    name: ''
    num_inputs: '1'
    type: float
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    update_time: 1.0/60
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0_0_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0_0_1, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_add_const_vxx_0_0_1, '0']
- [blocks_add_xx_0, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', blocks_probe_rate_0, '0']
- [blocks_throttle_0, '0', latency_manager_tag_to_msg_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', latency_manager_latency_manager_0, '0']
- [latency_manager_latency_manager_0, '0', blocks_multiply_const_vxx_0, '0']
- [latency_manager_latency_manager_0, '0', blocks_multiply_xx_0, '1']
- [latency_manager_tag_to_msg_0, msg, latency_manager_latency_manager_0, token]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-205-g0427b2a6
