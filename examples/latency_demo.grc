options:
  parameters:
    generate_options: qt_gui
    id: testing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_push_button
  parameters:
    label: Amplitude
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: latency_canary
  id: variable_tag_object
  parameters:
    key: pmt.intern("latency_canary")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.intern("unknown")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[latency_canary]'
    type: complex
    vector: (1,)*int(samp_rate/100)
  states: {}
- name: example_latency_manager_0
  id: example_latency_manager
  parameters:
    max_tags_in_flight: '5'
  states: {}
- name: example_tag_to_msg_0
  id: example_tag_to_msg
  parameters:
    display: 'False'
    filter: '""'
    issue_messages: 'True'
    name: ''
    num_inputs: '1'
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0, '0', example_tag_to_msg_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', example_latency_manager_0, '0']
- [example_latency_manager_0, '0', blocks_multiply_const_vxx_0, '0']
- [example_tag_to_msg_0, msg, blocks_message_debug_0, print]
- [example_tag_to_msg_0, msg, example_latency_manager_0, token]

metadata:
  file_format: 1
